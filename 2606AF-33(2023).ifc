Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2024-01-30T15:06:07
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20191106_1200(x64) - Exporter 20.2.1.1 - Alternate UI 20.2.1.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Jan 30 15:06:07 2024 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\f24a711b-3b8c-41de-896d-9c90fd1cefdb\bae8e3bb-ca85-4b0d-9b08-2a17f2603493\ifc * Database version: 5507 * Database creation date: Tue Jan 30 15:06:06 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Jan 30 15:06:07 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Jan 30 15:06:07 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCE

# IfcFlowController: 2606AF-33 Oras Optima, 2606AF-33(2023):2606AF-33 Oras Optima:351344
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass - Matt black, Fine Textured - Black
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - FaucetNominalDepth: 148.346 mm; FaucetNominalHeight: 188.504 mm; FaucetNominalWidth: 46.4999 mm; HandShowerNominalDepth: 64.3 mm; HandShowerNominalHeight: 296.7 mm; HandShowerNominalWidth: 49.3 mm; InletConnectionSize: 10 mm
Type - General - Author: BIMStone; BIMObjectName: 2606AF-33(2023); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 18/01/2024
Type - Green Building Properties - EAN Number: 6414150102516; EN Standard: EN 817; ETIM Class Number: EC011328 Washbasin mixing tap; LVI Number: 6110470; Noise Class: I (ISO 3822); NRF Number: 4200669; RSK Number: 8275680; Sales Package dimensions (LxWxH): 590 x 180 x 63; STF Certificate: EUFI29-23002169-TH1; UNSPSC Class Number: 30181700 Faucets or taps; URL Declaration of Asbestos: http://static.oras.com/doc/asbestos; URL Declaration of Conformity: http://static.oras.com/DoC/2606AF-33; URL Declaration Of Performance (DOP): http://static.oras.com/doc/DoP; URL Declaration of SCIP: http://static.oras.com/doc/SCIP; URL EcoLabel Declaration: http://static.oras.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.oras.com/doc/packaging; URL Materials Declaration: http://www.oras.com/fileadmin/resources/185559_2606AF-33_materialsdeclaration.pdf; URL REACH: http://static.oras.com/doc/reach; URL STF: http://static.oras.com/STF/2606AF-33; URL UWL: http://static.oras.com/UWL/2606AF-33; VVS Number: 703892211
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/2606AF-33; 3D View: https://static.oras.com/AR/2606AF-33; Catalog Drawing URL: http://static.oras.com/catdrw/2606AF-33; Dimension Drawing URL: http://static.oras.com/dimdrw/2606AF-33; FDV Document URL: http://www.oras.com/datasheet/2606AF-33/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/2606AF-33; Group: Sales item; Installation and Maintenance Guide URL: http://static.oras.com/manual/2606AF-33; Interactive AR View URL: https://static.oras.com/AR/2606AF-33; Manufacturer: Oras; Market: International;Finland;Norway;Sweden;Poland;Russia;Estonia;Lithuania;Latvia;Ukraine; Mobile Product Information URL: http://mpi.oras.com/2606AF-33; Model: 2606AF-33 Oras Optima; Name_en: 2606AF-33 Oras Optima; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 2606AF-33; Product Family: null Single-lever;Bidetta; Product Image URL: http://static.oras.com/image/2606AF-33; Product URL: http://static.oras.com/2606AF-33; Spare-Part Information URL: http://static.oras.com/sp/2606AF-33; Technical DataSheet URL: http://www.oras.com/datasheet/2606AF-33/en; Type Name: 2606AF-33 Oras Optima; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Brass - Matt black
Type - Mechanical - Advanced Features: 3S-installation system for safe and simple mounting; Aerator: PCA® - constant flow rate regardless of pressure variations; Backflow Prevention EN1717: HC; Connection: Flexible inlet pipes; Connection Size: G3/8; Excluded Items: Without pop-up waste; Flow Rate At 300kPa With Flow Controller: 0.000353147 m3/s; Hand Shower: Bidetta hand shower; Installation Type: Deck mounted; Lever Handle: Single operating lever/handle;Pin shape;Hot/Cold symbols; Max. Hot Water Supply: 70 kg/K/s3; Mechanical Parts: 30Cartridge; Shower Parts: Hand shower;Shower holder;Shower hose (1750 mm); Spout Projection: 114 mm; Spout Type: Fixed spout; Surface treatment: Matt black; Temperature Adjustments: Limitation option for maximum temperature and flow-rate; Working Pressure: 50 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Matt black; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 2606AF-33(2023); Features: Washbasin faucet; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 2606AF-33; Name: 2606AF-33 Oras Optima; ReplacementCost: n/a; Shape: Sculptured; Size: Faucet:45x150x190 mm / Hand shower:50x65x295 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ValveTypeCommon - ValvePattern: n/a; ValveOperation: n/a; ValveMechanism: n/a; FlowCoefficient: 0; CloseOffRating: 0 Pa
Type - Pset_ValveTypeFaucet - Finish: Polished
Pset_DistributionFlowElementCommon - Reference: 2606AF-33 Oras Optima; sets with these values: 2
Pset_ElementShading - Color: Matt black
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Pset_ManufacturerTypeInformation - ModelReference: 2606AF-33; Manufacturer: Oras
Pset_ProductRequirements - Name: 2606AF-33 Oras Optima; Category: Plumbing Fixtures
Constraints - DistanceX-Axis: 100 mm; DistanceY-Axis: 100 mm; Elevation from Level: 0 mm; FaucetDefaultElevation: 900 mm; HandShowerDefaultElevation: 900 mm; Hand Shower Visibility: yes; Host: Level : Level 1; Level: Level: Level 1; Offset from Host: 0 mm
Dimensions - Area: 0.081596 m2; Volume: 0.00224524 m3
Identity Data - Mark: 2
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 2606AF-33(2023): 2606AF-33 Oras Optima; Family and Type: 2606AF-33(2023): 2606AF-33 Oras Optima; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 2606AF-33(2023): 2606AF-33 Oras Optima; Type Id: 2606AF-33(2023): 2606AF-33 Oras Optima; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
